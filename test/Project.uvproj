# Keil uVision project Project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Project +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c Delay.c Delay.h LCD1602.c LCD1602.h AT24C02.c AT24C02.h I2C.c I2C.h MatrixKey.c MatrixKey.h rc522.c rc522.h uart.c uart.h wifi_control.c wifi_control.h
